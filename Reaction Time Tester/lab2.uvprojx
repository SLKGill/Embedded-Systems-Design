# Keil uVision project lab2.uvprojx, settings and files
target Tartget 1 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab2 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=4 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,HSE_VALUE=8000000
  c include: ./Inc;./Drivers/BSP/STM32F429I-Discovery;./Drivers/CMSIS/Device/ST/STM32F4xx/Include;./Drivers/STM32F4xx_HAL_Driver/Inc;./Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;./ARM_CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./Src/: Hal_eeprom.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group inc
    ./Inc/: Hal_eeprom.h main.h stm32f4xx_it.h
  group STM32F429I-DISCO
    ./STM32F429I-Disco/: LED_F429Discovery.c Buttons_F429Discovery.c
  group BSP
    ./Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group Utilities
    ./Drivers/BSP/Components/ili9341/: ili9341.c
  group STM32F4xx_Hal_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rng.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
